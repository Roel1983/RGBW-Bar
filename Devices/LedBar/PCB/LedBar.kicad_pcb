# Repository Roel1983/RGBW-Bar

## KiCad design Devices/LedBar/PCB/LedBar.kicad_pcb

Parts:
MB101, MB102, MB103, MB104, MB106: MouseBit
MB105: MouseBit; MouseBit_modified1

Parts:
H201, H202, H204: MountingHole; MountingHole_4.3mm_M4
H203: MountingHole; MountingHole_4.3mm_M4_modified1

Parts:
H1102: MountingHole; MountingHole_3.2mm_Wall_0.8mm
J1101: strip1_RGBW; RGBW-wire-solder-pads-R
J1102: Conn_01x05; PinHeader_1x05_P2.00mm_Vertical_no_silk
J1103: Strip1_BRG; BRG-wire-solder-pads-R

Connections:
/LeftBoard/12V+: J1101.+ (Pin_1), J1102.1, J1103.+ (Pin_1)
/LeftBoard/strip1_b_out: J1101.B (Pin_4), J1102.4, J1103.B (Pin_4)
/LeftBoard/strip1_g_out: J1101.G (Pin_3), J1102.3, J1103.G (Pin_3)
/LeftBoard/strip1_r_out: J1101.R (Pin_2), J1102.2, J1103.R (Pin_2)
/LeftBoard/strip1_w_out: J1101.W (Pin_5), J1102.5

Parts:
H1204: MountingHole; MountingHole_3.2mm_Wall_0.8mm
J1201: strip2_RGBW; RGBW-wire-solder-pads-R
J1202: Conn_02x06_Odd_Even; PinHeader_2x06_P2.00mm_Vertical
J1203: Strip3_RGBW; RGBW-wire-solder-pads-L
J1204: Strip2_BRG; BRG-wire-solder-pads-R
J1205: Strip3_BRG; BRG-wire-solder-pads-L

Connections:
/CenterBoard/12V+: J1201.+ (Pin_1), J1202.1, J1202.2, J1202.3, J1202.4, J1203.+ (Pin_1), J1204.+ (Pin_1), J1205.+ (Pin_1)
/CenterBoard/strip2_b_out: J1201.B (Pin_4), J1202.9, J1204.B (Pin_4)
/CenterBoard/strip2_g_out: J1201.G (Pin_3), J1202.7, J1204.G (Pin_3)
/CenterBoard/strip2_r_out: J1201.R (Pin_2), J1202.5, J1204.R (Pin_2)
/CenterBoard/strip2_w_out: J1201.W (Pin_5), J1202.11
/CenterBoard/strip3_b_out: J1202.10, J1203.B (Pin_4), J1205.B (Pin_4)
/CenterBoard/strip3_g_out: J1202.8, J1203.G (Pin_3), J1205.G (Pin_3)
/CenterBoard/strip3_r_out: J1202.6, J1203.R (Pin_2), J1205.R (Pin_2)
/CenterBoard/strip3_w_out: J1202.12, J1203.W (Pin_5)

Parts:
H1301: MountingHole; MountingHole_3.2mm_Wall_0.8mm
J1301: Conn_01x05; PinHeader_1x05_P2.00mm_Vertical_no_silk
J1302: Strip4_RGBW; RGBW-wire-solder-pads-R
J1303: Strip4_BRG; BRG-wire-solder-pads-R

Connections:
/RightBoard/12V+: J1301.1, J1302.+ (Pin_1), J1303.+ (Pin_1)
/RightBoard/strip4_b_out: J1301.4, J1302.B (Pin_4), J1303.B (Pin_4)
/RightBoard/strip4_g_out: J1301.3, J1302.G (Pin_3), J1303.G (Pin_3)
/RightBoard/strip4_r_out: J1301.2, J1302.R (Pin_2), J1303.R (Pin_2)
/RightBoard/strip4_w_out: J1301.5, J1302.W (Pin_5)

Parts:
J1001: Conn_02x06_Odd_Even; perpendicular_pcb_1mm_male_2x6
J1002: Conn_02x06_Odd_Even; PinHeader_2x06_P200mm_PCB_edge

Connections:
/Perpendicular/strip2_+12V_1: J1001.2, J1002.2
/Perpendicular/strip2_+12V_2: J1001.4, J1002.4
/Perpendicular/strip2_b_out: J1001.10, J1002.10
/Perpendicular/strip2_g_out: J1001.8, J1002.8
/Perpendicular/strip2_r_out: J1001.6, J1002.6
/Perpendicular/strip2_w_out: J1001.12, J1002.12
/Perpendicular/strip3_+12V_1: J1001.1, J1002.1
/Perpendicular/strip3_+12V_2: J1001.3, J1002.3
/Perpendicular/strip3_b_out: J1001.9, J1002.9
/Perpendicular/strip3_g_out: J1001.7, J1002.7
/Perpendicular/strip3_r_out: J1001.5, J1002.5
/Perpendicular/strip3_w_out: J1001.11, J1002.11

Parts:
C601: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J601: 0-10V(1); 15EDGRC-3.5-2P
JP601: Jumper_3_Open; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
R601: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R602, R603: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP601: a_out; TestPoint_Pad_D1.0mm
TP602: gnd; TestPoint_Pad_D1.0mm
U601: LM393; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+12VA: R601.1; also elsewhere on the board
/Mainboard/0-10V/a_in: JP601.1 (A), U601.5 (+); also elsewhere on the board
GND: C601.2, J601.1, R603.2, TP602.1; also elsewhere on the board
unnamed: C601.1, J601.2, JP601.2 (C), TP601.1
unnamed: JP601.3 (B), R601.2, R602.1, U601.7
unnamed: R602.2, R603.1, U601.6 (_)

Parts:
BT901: 3V; BatteryHolder_LINX_BAT-HLD-012-SMT
C901: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U901: DS1307Z+; SOIC-8_3.9x4.9mm_P1.27mm
Y901: 23.768kHz; Crystal_C38-LF_D3.0mm_L8.0mm_Horizontal_1EP_style1

Connections:
+5V: C901.1, U901.8 (VCC); also elsewhere on the board
+BATT: BT901.1 (+), U901.3 (VBAT)
/Mainboard/Microcontroller/scl: U901.6 (SCL); also elsewhere on the board
/Mainboard/Microcontroller/sda: U901.5 (SDA); also elsewhere on the board
GND: BT901.2 (-), C901.2, U901.4 (GND), Y901.3; also elsewhere on the board
unnamed: U901.1 (X1), Y901.2
unnamed: U901.2 (X2), Y901.1

Schematic: Pca.sch, LedBar - MainBoard

Parts:
C501, C502, C504: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C503, C505: 2200uF/16V; CP_Radial_D10.0mm_P5.00mm
J501: Left; PinHeader_1x05_P2.54mm_Horizontal
J502: Center; perpendicular_pcb_1mm_female_2x6
J503: Right; PinHeader_1x05_P2.54mm_Horizontal
Q501, Q502, Q503, Q504, Q505, Q506, Q507, Q508, Q509, Q510, Q511, Q512, Q513, Q514, Q515, Q516: Si2302DS; SOT-23_Handsoldering
TP501: ~pca_oe~; TestPoint_Pad_D1.0mm
TP502: s1w; TestPoint_Pad_D1.0mm
TP503: gnd; TestPoint_Pad_D1.0mm
TP504: s1w_o; TestPoint_Pad_D1.0mm
U501: PCA9685PW; TSSOP-28_4.4x9.7mm_P0.65mm

Connections:
+5V: C501.2, U501.28 (VDD); also elsewhere on the board
+12V: C502.1, C503.1, C504.1, C505.1, J501.1, J502.1, J502.2, J502.3, J502.4, J503.5; also elsewhere on the board
/Mainboard/Microcontroller/scl: U501.26 (SCL); also elsewhere on the board
/Mainboard/Microcontroller/sda: U501.27 (SDA); also elsewhere on the board
/Mainboard/Pca/strip1_b: Q509.1 (G), U501.8 (LED2)
/Mainboard/Pca/strip1_b_out: J501.4, Q509.3 (D)
/Mainboard/Pca/strip1_g: Q505.1 (G), U501.7 (LED1)
/Mainboard/Pca/strip1_g_out: J501.3, Q505.3 (D)
/Mainboard/Pca/strip1_r: Q501.1 (G), U501.6 (LED0)
/Mainboard/Pca/strip1_r_out: J501.2, Q501.3 (D)
/Mainboard/Pca/strip1_w: Q513.1 (G), TP502.1, U501.9 (LED3)
/Mainboard/Pca/strip1_w_out: J501.5, Q513.3 (D), TP504.1
/Mainboard/Pca/strip2_b: Q510.1 (G), U501.12 (LED6)
/Mainboard/Pca/strip2_b_out: J502.10, Q510.3 (D)
/Mainboard/Pca/strip2_g: Q506.1 (G), U501.11 (LED5)
/Mainboard/Pca/strip2_g_out: J502.8, Q506.3 (D)
/Mainboard/Pca/strip2_r: Q502.1 (G), U501.10 (LED4)
/Mainboard/Pca/strip2_r_out: J502.6, Q502.3 (D)
/Mainboard/Pca/strip2_w: Q514.1 (G), U501.13 (LED7)
/Mainboard/Pca/strip2_w_out: J502.12, Q514.3 (D)
/Mainboard/Pca/strip3_b: Q511.1 (G), U501.17 (LED10)
/Mainboard/Pca/strip3_b_out: J502.9, Q511.3 (D)
/Mainboard/Pca/strip3_g: Q507.1 (G), U501.16 (LED9)
/Mainboard/Pca/strip3_g_out: J502.7, Q507.3 (D)
/Mainboard/Pca/strip3_r: Q503.1 (G), U501.15 (LED8)
/Mainboard/Pca/strip3_r_out: J502.5, Q503.3 (D)
/Mainboard/Pca/strip3_w: Q515.1 (G), U501.18 (LED11)
/Mainboard/Pca/strip3_w_out: J502.11, Q515.3 (D)
/Mainboard/Pca/strip4_b: Q512.1 (G), U501.21 (LED14)
/Mainboard/Pca/strip4_b_out: J503.2, Q512.3 (D)
/Mainboard/Pca/strip4_g: Q508.1 (G), U501.20 (LED13)
/Mainboard/Pca/strip4_g_out: J503.3, Q508.3 (D)
/Mainboard/Pca/strip4_r: Q504.1 (G), U501.19 (LED12)
/Mainboard/Pca/strip4_r_out: J503.4, Q504.3 (D)
/Mainboard/Pca/strip4_w: Q516.1 (G), U501.22 (LED15)
/Mainboard/Pca/strip4_w_out: J503.1, Q516.3 (D)
/Mainboard/Pca/~oe~: TP501.1, U501.23 (~OE); also elsewhere on the board
GND: C501.1, C502.2, C503.2, C504.2, C505.2, Q501.2 (S), Q502.2 (S), Q503.2 (S), Q504.2 (S), Q505.2 (S), Q506.2 (S), Q507.2 (S), Q508.2 (S), Q509.2 (S), Q510.2 (S), Q511.2 (S), Q512.2 (S), Q513.2 (S), Q514.2 (S), Q515.2 (S), Q516.2 (S), TP503.1, U501.1 (A0), U501.2 (A1), U501.3 (A2), U501.4 (A3), U501.5 (A4), U501.14 (VSS), U501.24 (A5), U501.25 (EXTCLK); also elsewhere on the board

Schematic: Microcontroller.sch, LedBar - MainBoard

Parts:
C701, C702, C703: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C704: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C705, C706: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D701: Blue; LED_D3.0mm
D702: Green; LED_D3.0mm
D703: Yellow; LED_D3.0mm
D704: Orange; LED_D3.0mm
D705: Red; LED_D3.0mm
D706: 1N4148; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J701: AVR-ISP-6; ISP_P1.27mm_single_row
JP701, JP702, JP703, JP704, JP705: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R701: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R702, R703, R705, R707, R708, R709, R710, R711: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R704, R706: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW701: button; SW_PUSH_6mm_H8mm
SW702: reset; SW_SPST_CK_RS282G05A3
SW703: SW_DIP_x05; SW_DIP_SPSTx05_Slide_6.7x14.26mm_W7.62mm_P2.54mm_LowProfile
TP701, TP707, TP708, TP712: gnd; TestPoint_Pad_D1.0mm
TP702: pwm; TestPoint_Pad_D1.0mm
TP703: a_in; TestPoint_Pad_D1.0mm
TP704: ~pca_rdy~; TestPoint_Pad_D1.0mm
TP705: dbg1; TestPoint_Pad_D1.0mm
TP706: ~button~; TestPoint_Pad_D1.0mm
TP709: scl; TestPoint_Pad_D1.0mm
TP710: ~reset~; TestPoint_Pad_D1.0mm
TP711: sda; TestPoint_Pad_D1.0mm
U701: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
Y701: 14.7456Mhz; Crystal_HC49-U_Vertical

Connections:
+5V: C702.1, C703.2, D701.2 (A), J701.2 (VCC), R704.1, R705.1, R706.1, R711.1, U701.4 (VCC), U701.6 (VCC), U701.18 (AVCC); also elsewhere on the board
/Mainboard/0-10V/a_in: C704.1, R701.1, TP703.1; also elsewhere on the board
/Mainboard/Brown-out/~Brown_out~: R702.1, R703.1, U701.1 (PD3(3)); also elsewhere on the board
/Mainboard/Microcontroller/addr1: JP701.1 (A), SW703.6, U701.2 (PD4(4))
/Mainboard/Microcontroller/addr2: JP702.1 (A), SW703.7, U701.10 (PD6(6))
/Mainboard/Microcontroller/addr3: JP703.1 (A), SW703.8, U701.11 (PD7(7))
/Mainboard/Microcontroller/addr4: JP704.1 (A), SW703.9, U701.12 (PB0(8))
/Mainboard/Microcontroller/addr5: JP705.1 (A), SW703.10, U701.13 (PB1(9))
/Mainboard/Microcontroller/debug1: TP705.1, U701.24 (PC1(A1/15))
/Mainboard/Microcontroller/led1_sck: J701.3 (SCK), R707.2, U701.17 (PB5(13))
/Mainboard/Microcontroller/led2_miso: J701.1 (MISO), R708.2, U701.16 (PB4(12))
/Mainboard/Microcontroller/led3_mosi: J701.4 (MOSI), R709.2, U701.15 (PB3(11))
/Mainboard/Microcontroller/led4: R710.2, U701.14 (PB2(10))
/Mainboard/Microcontroller/pwm: R701.2, TP702.1, U701.9 (PD5(5))
/Mainboard/Microcontroller/rxd: U701.30 (PD0(0)); also elsewhere on the board
/Mainboard/Microcontroller/scl: R704.2, TP709.1, U701.28 (PC5(A5/19)); also elsewhere on the board
/Mainboard/Microcontroller/sda: R706.2, TP711.1, U701.27 (PC4(A4/18)); also elsewhere on the board
/Mainboard/Microcontroller/tx_en: U701.26 (PC3(A3/17)); also elsewhere on the board
/Mainboard/Microcontroller/txd: U701.31 (PD1(1)); also elsewhere on the board
/Mainboard/Microcontroller/~button~: SW701.2, TP706.1, U701.23 (PC0(A0/14))
/Mainboard/Microcontroller/~pca_rdy~: D706.2 (A), R711.2, TP704.1, U701.25 (PC2(A2/16))
/Mainboard/Microcontroller/~reset~: J701.5 (~RST), R705.2, SW702.2, TP710.1, U701.29 (~RESET~/PC6(22))
/Mainboard/Pca/~oe~: D706.1 (K), R702.2, U701.32 (PD2(2)); also elsewhere on the board
GND: C701.1, C702.2, C703.1, C704.2, C705.1, C706.1, D702.1 (K), D703.1 (K), D704.1 (K), D705.1 (K), J701.6 (GND), JP701.2 (B), JP702.2 (B), JP703.2 (B), JP704.2 (B), JP705.2 (B), SW701.1, SW702.1, SW703.1, SW703.2, SW703.3, SW703.4, SW703.5, TP701.1, TP707.1, TP708.1, TP712.1, U701.3 (GND), U701.5 (GND), U701.21 (GND); also elsewhere on the board
unnamed: C701.2, U701.20 (AREF)
unnamed: C705.2, U701.7 (XTAL1/PB6(20)), Y701.2
unnamed: C706.2, U701.8 (XTAL2/PB7(21)), Y701.1
unnamed: D701.1 (K), R703.2
unnamed: D702.2 (A), R707.1
unnamed: D703.2 (A), R708.1
unnamed: D704.2 (A), R709.1
unnamed: D705.2 (A), R710.1

Schematic: Brown-out.sch, LedBar - MainBoard

Parts:
C801, C803: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C802: 4.7uF/16V; CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder
D801: 4V7; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R801, R804, R806: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R802: 15k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R803: 18k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R805: 150k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R807: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP801: BO; TestPoint_Pad_D1.0mm
U601: LM393; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C801.1, R806.1; also elsewhere on the board
+12V: R807.2; also elsewhere on the board
+12VA: C802.1, C803.1, R801.1, R803.1, R807.1, U601.8 (V+); also elsewhere on the board
/Mainboard/Brown-out/~Brown_out~: R805.1, R806.2, TP801.1, U601.1; also elsewhere on the board
GND: C801.2, C802.2, C803.2, D801.2 (A), R802.2, U601.4 (V-); also elsewhere on the board
unnamed: D801.1 (K), R804.2
unnamed: R801.2, R802.1, U601.2 (-)
unnamed: R803.2, R804.1, R805.2, U601.3 (+)

Schematic: RS485.sch, LedBar - MainBoard

Parts:
C401, C404: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C402: 10uF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C403: 4.7uF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
D401: PSM712; SOT-23_Handsoldering
J401: RS485; 15EDGRC-3.5-3P
R401, R402: 10R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP401, TP405: GND_iso; TestPoint_Pad_D1.0mm
TP402: B; TestPoint_Pad_D1.0mm
TP403: A; TestPoint_Pad_D1.0mm
TP404: +5V_iso; TestPoint_Pad_D1.0mm
TP406: txd; TestPoint_Pad_D1.0mm
TP407: rxd; TestPoint_Pad_D1.0mm
TP408: tx_en; TestPoint_Pad_D1.0mm
TP409: gnd; TestPoint_Pad_D1.0mm
U401: ISO3082DW; SOIC-16W_7.5x10.3mm_P1.27mm
U402: B0505S-1W-SIP4; B0505S-1W

Connections:
+5V: C403.1, C404.1, U401.1 (Vcc1), U402.2 (5V+); also elsewhere on the board
+5V_iso: C401.2, C402.2, TP404.1, U401.16 (Vcc2), U402.4 (5V+_iso)
/Mainboard/Microcontroller/rxd: TP407.1, U401.3 (R); also elsewhere on the board
/Mainboard/Microcontroller/tx_en: TP408.1, U401.4 (~RE), U401.5 (DE); also elsewhere on the board
/Mainboard/Microcontroller/txd: TP406.1, U401.6 (D); also elsewhere on the board
/Mainboard/RS485/A: D401.2 (A2), J401.2, R402.1, TP403.1
/Mainboard/RS485/B: D401.1 (A1), J401.3, R401.1, TP402.1
GND: C403.2, C404.2, TP409.1, U401.2 (GND1), U401.7 (GND1), U401.8 (GND1), U402.1 (GND); also elsewhere on the board
GND_iso: C401.1, C402.1, D401.3 (common), J401.1, TP401.1, TP405.1, U401.9 (GND2), U401.10 (GND2), U401.15 (GND2), U402.3 (GND_iso)
unnamed: R401.2, U401.13 (B)
unnamed: R402.2, U401.12 (A)

Notes on the sheet:
Isolated

Schematic: Power.sch, LedBar - MainBoard

Parts:
C301, C303, C304, C306, C307: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C302: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C305: 10uF/16V; CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder
C308: 10uF/10V; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
D301: SMBJ15A; D_SMB_Handsoldering
D302: 5v1; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
F301: Max. 5A F; Fuseholder_Cylinder-5x20mm_BLX_A_Horizontal
J301: 12VDC/5A; 2EDGRC-5.08-2P
R301, R303: 10R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R302: R001/2W; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R304: 62R/0.25W; R_1210_3225Metric_Pad1.30x2.65mm_HandSolder
TP301: +12V; TestPoint_Pad_D1.0mm
TP302, TP304: gnd; TestPoint_Pad_D1.0mm
TP303: +5V; TestPoint_Pad_D1.0mm
U301: INA219AxD; SOIC-8_3.9x4.9mm_P1.27mm
U302: AMS1117-5.0; SOT-223-3_TabPin2

Connections:
+5V: C304.2, C307.1, C308.1, D302.1 (K), TP303.1, U301.1 (A1), U301.5 (VS), U302.2 (VO); also elsewhere on the board
+12V: C303.1, R302.1, R303.1, TP301.1; also elsewhere on the board
/Mainboard/Microcontroller/scl: U301.4 (SCL); also elsewhere on the board
/Mainboard/Microcontroller/sda: U301.3 (SDA); also elsewhere on the board
/Mainboard/Power/+12V_not_measured: C301.1, D301.1 (K), F301.1, R301.1, R302.2, R304.2
/Mainboard/Power/unprotected_12VDC: F301.2, J301.2
GND: C301.2, C303.2, C304.1, C305.2, C306.1, C307.2, C308.2, D301.2 (A), D302.2 (A), J301.1, TP302.1, TP304.1, U301.2 (A0), U301.6 (GND), U302.1 (GND); also elsewhere on the board
unnamed: C302.1, R303.2, U301.7 (IN-)
unnamed: C302.2, R301.2, U301.8 (IN+)
unnamed: C305.1, C306.2, R304.1, U302.3 (VI)

Board: 2 copper layers, 63.5 x 99.3 mm, 167 parts (123 on the bottom side), 117 nets.

## KiCad design Devices/RS485-TTL/PCB/RS485-TTL.kicad_pcb

Parts:
C1, C4, C5: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 10uF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C3: 4.7uF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
D1, D3, D4, D5: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: PSM712; SOT-23_Handsoldering
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: RS485; 15EDGRC-3.5-3P
J2: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
JP1, JP2: Jumper_2_Open; PinSocket_1x02_P2.54mm_Vertical
R1: 590R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 133R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: R590R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R7, R8, R9: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R6: 10R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ISO3082DW; SOIC-16W_7.5x10.3mm_P1.27mm
U2: B0505S-1W-SIP4; B0505S-1W

Connections:
+5V: C3.1, C4.1, C5.1, J2.1, U1.1 (Vcc1), U2.2 (5V+)
+5V_iso: C1.2, C2.2, R3.2, R4.1, U1.16 (Vcc2), U2.4 (5V+_iso)
/A: D2.2 (A2), J1.2, JP2.2 (B), R6.1
/B: D2.1 (A1), J1.3, JP1.1 (A), R5.1
/rxd: J2.3, R8.1, U1.3 (R)
/tx_en: J2.4, R9.1, U1.4 (~RE), U1.5 (DE)
/txd: J2.2, R7.1, U1.6 (D)
GND: C3.2, C4.2, C5.2, D3.1 (K), D4.1 (K), D5.1 (K), J2.5, U1.2 (GND1), U1.7 (GND1), U1.8 (GND1), U2.1 (GND)
GND_iso: C1.1, C2.1, D1.1 (K), D2.3 (common), J1.1, R1.1, U1.9 (GND2), U1.10 (GND2), U1.15 (GND2), U2.3 (GND_iso)
unnamed: D1.2 (A), R4.2
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R9.2
unnamed: JP1.2 (B), R1.2, R2.1
unnamed: JP2.1 (A), R2.2, R3.1
unnamed: R5.2, U1.13 (B)
unnamed: R6.2, U1.12 (A)

Notes on the sheet:
Isolated

Board: 2 copper layers, 48.3 x 27.9 mm, 29 parts (0 on the bottom side), 17 nets.

Notices in the files:
Devices/LedBar/PCB/Brown-out.sch:
GNU General Public License v3.0
